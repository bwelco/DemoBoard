# Keil uVision project temperature.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temperature +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c system_init.c tempture.c steering.c handle_message.c interrupt.c light.c lcd1602.c
